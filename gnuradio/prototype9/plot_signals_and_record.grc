options:
  parameters:
    generate_options: qt_gui
    id: plot_signals
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: offset
  id: variable
  parameters:
    value: '-0.250'
  states: {}
- name: points
  id: variable
  parameters:
    value: 2048*1
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500'
  states: {}
- name: sample_count
  id: variable
  parameters:
    value: '7'
  states: {}
- name: block_BLE_source
  id: epy_block
  parameters:
    _source_code: |
      """
      This block connects to the PsyLink device with the provided MAC address and streams its signals.
      """

      # NOTE: PsyLink's "python" folder needs to be in $PYTHONPATH so that the "psylink" module can be imported.
      # Alternatively, uncomment the following line and change the path to the location of the "python" folder:
      #sys.path.insert(0, os.path.expanduser('~/psylink/python'))

      try:
          from psylink.gnuradio_blocks import BLESource
      except ImportError:
          print("Please ensure that the 'psylink' python module is importable, e.g. by adding '/path/to/psylink/python' to $PYTHONPATH")
          raise
    ble_mac: '"2E:A9:71:D7:65:95"'
  states: {}
- name: block_shift
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nBy default, GNURadio plotting blocks (\"QT GUI Time Sink\") buffer a number\nof signals and once the buffer is filled, it displays them all at once.\n\nInstead, we want to watch signals as soon as they come in.\n\nThis block works like a shift register for incoming signals. It outputs the\nlast N signals repeatedly, fast enough to keep the buffers of the \"QT GUI\nTime Sinks\" always filled. This forces the time sinks to operate in a\n\"rolling window\" mode.\n\n(This is a copy of the docstring of psylink.gnuradio.ShiftBlock and might be out of date.)\n\"\"\"\n\n\n# NOTE: PsyLink's \"python\" folder needs to be in $PYTHONPATH so that the \"psylink\" module can be imported.\n# Alternatively, uncomment the following line and change the path to the location of the \"python\" folder:\n#sys.path.insert(0, os.path.expanduser('~/psylink/python'))\n\ntry:\n    from psylink.gnuradio_blocks import ShiftBlock\nexcept ImportError:\n    print(\"Please ensure that the 'psylink' python module is importable, e.g. by adding '/path/to/psylink/python' to $PYTHONPATH\")\n    raise\n\n"
    number_of_points: points
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 2*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 3*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 4*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 5*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 6*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 7*offset
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/hut/out.bin
    type: float
    vlen: '14'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
    vlen: '14'
  states: {}
- name: blocks_streams_to_vector_0
  id: blocks_streams_to_vector
  parameters:
    num_streams: '14'
    type: float
  states: {}
- name: note_0
  id: note
  parameters:
    note: CHANGE THE PATH
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color5: dark red
    color6: dark green
    color7: dark blue
    entags: 'False'
    grid: 'True'
    label1: Electrode 1
    label2: Electrode 2
    label3: Electrode 3
    label4: Electrode 4
    label5: Electrode 5
    label6: Electrode 6
    label7: Electrode 7
    label8: Electrode 8
    nconnections: '8'
    size: points
    srate: samp_rate
    type: float
    update_time: '0.05'
    ymin: '-2'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color5: dark red
    color6: dark green
    entags: 'False'
    grid: 'True'
    label1: Gyroscope X
    label2: Gyroscope Y
    label3: Gyroscope Z
    label4: Accelerometer X
    label5: Accelerometer Y
    label6: Accelerometer Z
    nconnections: '6'
    size: points
    srate: samp_rate
    type: float
    update_time: '0.05'
    ymax: '1.2'
    ymin: '-0.2'
  states: {}

connections:
- [block_BLE_source, '0', block_shift, '0']
- [block_BLE_source, '0', blocks_streams_to_vector_0, '0']
- [block_BLE_source, '1', block_shift, '1']
- [block_BLE_source, '1', blocks_streams_to_vector_0, '1']
- [block_BLE_source, '10', block_shift, '10']
- [block_BLE_source, '10', blocks_streams_to_vector_0, '10']
- [block_BLE_source, '11', block_shift, '11']
- [block_BLE_source, '11', blocks_streams_to_vector_0, '11']
- [block_BLE_source, '12', block_shift, '12']
- [block_BLE_source, '12', blocks_streams_to_vector_0, '12']
- [block_BLE_source, '13', block_shift, '13']
- [block_BLE_source, '13', blocks_streams_to_vector_0, '13']
- [block_BLE_source, '2', block_shift, '2']
- [block_BLE_source, '2', blocks_streams_to_vector_0, '2']
- [block_BLE_source, '3', block_shift, '3']
- [block_BLE_source, '3', blocks_streams_to_vector_0, '3']
- [block_BLE_source, '4', block_shift, '4']
- [block_BLE_source, '4', blocks_streams_to_vector_0, '4']
- [block_BLE_source, '5', block_shift, '5']
- [block_BLE_source, '5', blocks_streams_to_vector_0, '5']
- [block_BLE_source, '6', block_shift, '6']
- [block_BLE_source, '6', blocks_streams_to_vector_0, '6']
- [block_BLE_source, '7', block_shift, '7']
- [block_BLE_source, '7', blocks_streams_to_vector_0, '7']
- [block_BLE_source, '8', block_shift, '8']
- [block_BLE_source, '8', blocks_streams_to_vector_0, '8']
- [block_BLE_source, '9', block_shift, '9']
- [block_BLE_source, '9', blocks_streams_to_vector_0, '9']
- [block_shift, '0', qtgui_time_sink_x_0_0, '0']
- [block_shift, '1', blocks_add_const_vxx_0, '0']
- [block_shift, '10', qtgui_time_sink_x_0_0_0, '2']
- [block_shift, '11', qtgui_time_sink_x_0_0_0, '3']
- [block_shift, '12', qtgui_time_sink_x_0_0_0, '4']
- [block_shift, '13', qtgui_time_sink_x_0_0_0, '5']
- [block_shift, '2', blocks_add_const_vxx_0_0, '0']
- [block_shift, '3', blocks_add_const_vxx_0_0_0, '0']
- [block_shift, '4', blocks_add_const_vxx_0_0_0_0, '0']
- [block_shift, '5', blocks_add_const_vxx_0_0_0_0_0, '0']
- [block_shift, '6', blocks_add_const_vxx_0_0_0_0_0_0, '0']
- [block_shift, '7', blocks_add_const_vxx_0_0_0_0_0_0_0, '0']
- [block_shift, '8', qtgui_time_sink_x_0_0_0, '0']
- [block_shift, '9', qtgui_time_sink_x_0_0_0, '1']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_add_const_vxx_0_0_0_0, '0', qtgui_time_sink_x_0_0, '4']
- [blocks_add_const_vxx_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '5']
- [blocks_add_const_vxx_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '6']
- [blocks_add_const_vxx_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '7']
- [blocks_streams_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_streams_to_vector_0, '0', blocks_null_sink_0, '0']

metadata:
  file_format: 1
