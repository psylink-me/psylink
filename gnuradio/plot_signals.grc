options:
  parameters:
    generate_options: qt_gui
    id: plot_signals
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: offset
  id: variable
  parameters:
    value: '-0.7'
  states: {}
- name: points
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500'
  states: {}
- name: sample_count
  id: variable
  parameters:
    value: '7'
  states: {}
- name: block_BLE_source
  id: epy_block
  parameters:
    _source_code: |
      # WARNING: DO NOT EDIT "block_BLE_source.py" DIRECTLY! IT IS AUTOGENERATED BY GNURADIO!
      # INSTEAD, OPEN GNURADIO, DOUBLE-CLICK "BLE Source" AND CLICK ON "Open in Editor"!

      import importlib
      import math
      import os.path
      import sys
      import time

      import numpy as np
      from gnuradio import gr

      try:
          import psylink.bluetooth
          import psylink.protocol
      except ImportError:
          # NOTE: You may need to change this path to where you downloaded psyink to:
          libpath = os.path.expanduser('~/repos/psylink/python')
          sys.path.insert(0, libpath)
          import psylink.bluetooth
          import psylink.protocol

      DEFAULT_BLE_ADDRESS = 'A6:B7:D0:AE:C2:76'
      SIGNAL_COUNT = 7

      class BLESource(gr.basic_block):
          def __init__(self, ble_mac=DEFAULT_BLE_ADDRESS):
              gr.basic_block.__init__(self, name='BLE Source', in_sig=[], out_sig=[np.float32] * SIGNAL_COUNT)
              self.ble_mac = ble_mac
              self.last_sample_count = 2048  # some large conservative value
              self.BLE = None
              self.BLE_decoder = psylink.protocol.BLEDecoder(sample_value_offset=0)
              self.actual_channels = SIGNAL_COUNT  # will be updated with data from device

          def general_work(self, input_items, output_items):
              count = 0
              pipe = self.BLE.pipe
              limit = len(output_items[0]) - self.last_sample_count
              while not pipe.empty() and count < limit:
                  packet = pipe.get()
                  data = self.BLE_decoder.decode_packet(packet)
                  samples = data['samples']
                  transposed = np.transpose(samples)
                  for channel_id in range(min(SIGNAL_COUNT, self.actual_channels)):
                      channel = output_items[channel_id]
                      channel[count:count+len(samples)] = transposed[channel_id] / 256
                  count += len(samples)
                  self.last_sample_count = len(samples)
                  limit = len(output_items[0]) - self.last_sample_count
              return count

          def start(self):
              if self.BLE:
                  print("Error: Bluetooth Thread already running!")
                  return False

              # Reset state
              importlib.reload(psylink.bluetooth)
              importlib.reload(psylink.protocol)

              BackendClass = list(psylink.bluetooth.BACKENDS.values())[0]
              self.BLE = BackendClass(self.ble_mac)
              self.BLE.connect()
              self.actual_channels = self.BLE_decoder.decode_channel_count(self.BLE.read_channels())
              self.BLE.thread_start()

              return True

          def stop(self):
              if self.BLE:
                  self.BLE.disconnect()
                  self.BLE.thread_stop()
                  self.BLE = None
              return True
    ble_mac: '''A6:B7:D0:AE:C2:76'''
  states: {}
- name: block_shift
  id: epy_block
  parameters:
    _source_code: |
      # WARNING: DO NOT EDIT "block_shift.py" DIRECTLY! IT IS AUTOGENERATED BY GNURADIO!
      # INSTEAD, OPEN GNURADIO, DOUBLE-CLICK "BLE Source" AND CLICK ON "Open in Editor"!

      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0
  id: epy_block
  parameters:
    _source_code: |
      # WARNING: DO NOT EDIT "block_shift.py" DIRECTLY! IT IS AUTOGENERATED BY GNURADIO!
      # INSTEAD, OPEN GNURADIO, DOUBLE-CLICK "BLE Source" AND CLICK ON "Open in Editor"!

      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_0
  id: epy_block
  parameters:
    _source_code: |
      # WARNING: DO NOT EDIT "block_shift.py" DIRECTLY! IT IS AUTOGENERATED BY GNURADIO!
      # INSTEAD, OPEN GNURADIO, DOUBLE-CLICK "BLE Source" AND CLICK ON "Open in Editor"!

      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      # WARNING: DO NOT EDIT "block_shift.py" DIRECTLY! IT IS AUTOGENERATED BY GNURADIO!
      # INSTEAD, OPEN GNURADIO, DOUBLE-CLICK "BLE Source" AND CLICK ON "Open in Editor"!

      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      # WARNING: DO NOT EDIT "block_shift.py" DIRECTLY! IT IS AUTOGENERATED BY GNURADIO!
      # INSTEAD, OPEN GNURADIO, DOUBLE-CLICK "BLE Source" AND CLICK ON "Open in Editor"!

      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {state: disabled}
- name: block_shift_0_0_1
  id: epy_block
  parameters:
    _source_code: |
      # WARNING: DO NOT EDIT "block_shift.py" DIRECTLY! IT IS AUTOGENERATED BY GNURADIO!
      # INSTEAD, OPEN GNURADIO, DOUBLE-CLICK "BLE Source" AND CLICK ON "Open in Editor"!

      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_1
  id: epy_block
  parameters:
    _source_code: |
      # WARNING: DO NOT EDIT "block_shift.py" DIRECTLY! IT IS AUTOGENERATED BY GNURADIO!
      # INSTEAD, OPEN GNURADIO, DOUBLE-CLICK "BLE Source" AND CLICK ON "Open in Editor"!

      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_1
  id: epy_block
  parameters:
    _source_code: |
      # WARNING: DO NOT EDIT "block_shift.py" DIRECTLY! IT IS AUTOGENERATED BY GNURADIO!
      # INSTEAD, OPEN GNURADIO, DOUBLE-CLICK "BLE Source" AND CLICK ON "Open in Editor"!

      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 2*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 3*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 4*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 5*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 6*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 7*offset
    type: float
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: points
    freqhalf: 'False'
    grid: 'True'
    nconnections: '2'
    type: float
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '40'
    ymin: '-100'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color5: dark red
    color6: dark green
    color7: dark blue
    entags: 'False'
    grid: 'True'
    label1: Arm Right
    label2: Arm Left
    label3: Wrist
    label4: Thumb
    label5: Index Finger
    label6: Middle Finger
    label7: Ring Finger
    nconnections: '7'
    size: points
    srate: samp_rate
    type: float
    update_time: '0.05'
    ymin: 0+sample_count*offset
  states: {}

connections:
- [block_BLE_source, '0', block_shift, '0']
- [block_BLE_source, '1', block_shift_0, '0']
- [block_BLE_source, '2', block_shift_0_0, '0']
- [block_BLE_source, '3', block_shift_0_0_0, '0']
- [block_BLE_source, '4', block_shift_1, '0']
- [block_BLE_source, '5', block_shift_0_1, '0']
- [block_BLE_source, '6', block_shift_0_0_1, '0']
- [block_shift, '0', qtgui_freq_sink_x_0, '0']
- [block_shift, '0', qtgui_time_sink_x_0_0, '0']
- [block_shift_0, '0', blocks_add_const_vxx_0, '0']
- [block_shift_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [block_shift_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [block_shift_0_0_0_0, '0', blocks_add_const_vxx_0_0_0_0_0_0_0, '0']
- [block_shift_0_0_1, '0', blocks_add_const_vxx_0_0_0_0_0_0, '0']
- [block_shift_0_1, '0', blocks_add_const_vxx_0_0_0_0_0, '0']
- [block_shift_1, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_time_sink_x_0_0, '3']
- [blocks_add_const_vxx_0_0_0_0, '0', qtgui_time_sink_x_0_0, '4']
- [blocks_add_const_vxx_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '5']
- [blocks_add_const_vxx_0_0_0_0_0_0, '0', qtgui_time_sink_x_0_0, '6']

metadata:
  file_format: 1
