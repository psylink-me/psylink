# Repository psylink-me/psylink

File README.md:

# PsyLink

Open source [myoelectric](https://en.wikipedia.org/wiki/Electromyography) neural interface.

[Website](https://psylink.me) ::
[Documentation](https://codeberg.org/psylink/psylink/wiki) ::
[Matrix Chatroom](https://matrix.to/#/#psylink:matrix.org) ::
[FAQ](https://psylink.me/faq)

# Introduction

**Psylink** is intended as a human input device (like a keyboard) that predicts your
intention from muscle signals.  Using a neural network, trained through a
process where you press keys at the exact same time that you make movements
with the limb wearing the device, it learns correlations between the muscle
signals and intended keys, and can press them for you.

- [Video demos @ PeerTube](https://peertube.linuxrocks.online/video-channels/psylink/videos)
- [Development Log](https://psylink.me/blog)
- [Whats Next?](https://codeberg.org/psylink/psylink/wiki/Next-Steps)

# Software used to create/edit/run these files

- Schematics, PCB Layouts: KiCad 6.0 (some archived ones used 5.1.5)
- Arduino IDE 1.8.19
    - ArduinoBLE 1.2.1
    - Arduino\_LSM9DS1 1.1.0
- Python 3.8
    - For library versions, see the respective requirements.txt file
- GnuRadio 3.8.1.0

# Datasheet

This describes [prototype 4](https://psylink.me/p4).

- Features:
    - Battery-powered
    - Wireless, using Bluetooth Low Energy (BLE)
    - Supports 17 electrodes (8 pairs + 1 ground)
    - Transmits 8 signals at 8-bit resolution, 500Hz sampling rate
    - Linux graphical user interface for:
        - Mapping keyboard key presses to muscle signals
        - Training a neural network to predict key presses from signals
        - Simulating key presses based on neural network predictions
    - GNURadio integration for plotting the raw signals + FFT
- Hardware overview:
    - A fabric glove/sleeve with a central component (arduino + power supply)
      and 8 distributed signal clean-up units close to individual electrodes.
    - [KiCad Schematic](schematics/myocular0.5.1.sch)
    - [KiCad PCB of one distributed signal clean-up unit](schematics/myocular0.5.1d.kicad_pcb)
- Software dependencies:
    - Python3 (see [requirements.txt](python/requirements.txt))
        - [BLE-GATT](https://pypi.org/project/BLE-GATT/)
        - [matplotlib](https://matplotlib.org/)
        - [pynput](https://pypi.org/project/pynput/)
        - [tensorflow](https://www.tensorflow.org/)
        - [Pillow](https://python-pillow.org)
        - possibly the `python3-pil.imagetk` package
    - ArduinoIDE
        - [ArduinoBLE](https://www.arduino.cc/en/Reference/ArduinoBLE)
        - [Arduino LSM9DS1](https://www.arduino.cc/en/Reference/ArduinoLSM9DS1) (for accelerometer/gyroscope)
- Components:
    - 1x [Arduino Nano 33 BLE Sense](https://store.arduino.cc/arduino-nano-33-ble-sense)
    - 1x [LM324 Operational Amplifier](https://www.ti.com/product/LM324)
    - 8x [INA128 Instrumentational Amplifier](https://www.ti.com/product/INA128)
    - Any portable 6V power supply (like 2x CR2032)
    - 17x Electrodes, e.g. [Prym 390120](https://www.prym.com/en/non-sew-refill-for-390120-smooth-cap-10mm-silver-coloured-390104) (don't laugh, they work)
    - A forearm sleeve from non-conductive fabric
    - Additional standard components (see schematic)
- Power ratings
    - Supply Voltage: 4.5-6V
    - Power dissipation:
        - Idle: ~86.9mW (16.9mA x 5.14V)
        - Transmitting at 6-7kB/s: 92.5mW (18.0mA x 5.14V)
- Weight: ~85g (at 9.81m/s² gravitational acceleration)

# Acknowledgements

Very special thanks to every contributor. You all shaped the direction of this
project in your unique way, and we would not be at this point without you!

- [Roman Zimbelmann](https://rzim.dev): Founder and maintainer of PsyLink
- [Alex Lao](http://www.voltagedivide.com/): Consulting
- [AntonX](https://www.linkedin.com/in/anton-x/): Consulting, hardware design
- [Cade Brown](https://cade.site/): Testing, financial support
- [Fabien Devaux](http://github.com/fdev31/): Consulting
- [Farzam Khodajoo](https://www.linkedin.com/in/farzam-khodajoo): Consulting, hardware design
- [Hackaday.com](https://hackaday.com/2022/01/07/psylink-an-open-source-neural-interface-for-non-invasive-emg/): Spreading the word, networking
- [John Shahbazian](https://github.com/jshahbazi): Consulting, testing, software, financial support
- keks: Consulting, testing
- knoc: Consulting, testing
- [ktrask](https://twitter.com/ktrask23) ([mastodon](https://chaos.social/@ktrask)): Consulting, testing
- [PCBWay](https://pcbway.com): Sponsored production services
- [PerlinWarp](https://twitter.com/perlinwarp): Consulting, testing, documentation, networking, financial support
- Ricard Collins: Consulting, financial support, testing
- [Wojciech Siewierski](https://einval.eu): Consulting
- Thanks to all the patrons on [Liberapay](https://liberapay.com/psylink/) for financial support!

# License

Copyright (C) 2023  Roman Zimbelmann

This program is free software: you can redistribute it and/or modify
it under the terms of the GNU General Public License version 3 as
published by the Free Software Foundation.

This program is distributed in the hope that it will be useful,
but WITHOUT ANY WARRANTY; without even the implied warranty of
MERCHANTABILITY or FITNESS FOR A PARTICULAR PURPOSE.  See the
GNU General Public License for more details.

You should have received a copy of the GNU General Public License
along with this program.  If not, see <https://www.gnu.org/licenses/>.

## KiCad design schematics/b4/PsyLinkMCP.kicad_pcb

Board: 2 copper layers, 70.0 x 25.0 mm, 64 parts (0 on the bottom side), 34 nets.

Parts:
C1, C3, C4, C12, C22, C32, C42: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C2, C5: 10uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C10, C11, C20, C21, C30, C31, C40, C41: 100pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
EL10, EL11, EL20, EL21, EL30, EL31, EL40, EL41: Electrode; MountingHole_3.7mm_Pad
EX10, EX11, EX20, EX21, EX30, EX31, EX40, EX41: ElectrodeTestPin; PinHeader_1x01_P2.54mm_Vertical
J1: PowerInput; PinHeader_1x03_P2.54mm_Vertical
J2: PowerPassThru; PinHeader_1x03_P2.54mm_Vertical
J3: OutputPins; PinHeader_1x04_P2.54mm_Vertical
JP10, JP11, JP20, JP21, JP30, JP31, JP40, JP41: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R10, R11, R20, R21, R30, R31, R40, R41: 1M/1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R12, R22, R32, R42: 100k/1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R13, R33, R43: 200/1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R23: 400/1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U10, U20, U30, U40: MCP6N11; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/in10: C10.1, EX10.1, JP10.1
/in11: C11.2, EX11.1, JP11.1
/in20: C20.1, EX21.1, JP20.1
/in21: C21.2, EX20.1, JP21.1
/in30: C30.1, EX30.1, JP30.1
/in31: C31.2, EX31.1, JP31.1
/in40: C40.1, EX40.1, JP40.1
/in41: C41.2, EX41.1, JP41.1
/out1: J3.4, R12.2, U10.6
/out2: J3.3, R22.2, U20.6
/out3: J3.2, R32.2, U30.6
/out4: J3.1, R42.2, U40.6
GND: C1.1, C2.1, C4.1, C5.1, C12.2, C22.2, C32.2, C42.2, J1.1, J2.1, U10.4, U20.4, U30.4, U40.4
unnamed: C10.2, R10.1, U10.2
unnamed: C11.1, R11.2, U10.3
unnamed: C20.2, R20.1, U20.2
unnamed: C21.1, R21.2, U20.3
unnamed: C30.2, R30.1, U30.2
unnamed: C31.1, R31.2, U30.3
unnamed: C40.2, R40.1, U40.2
unnamed: C41.1, R41.2, U40.3
unnamed: EL10.1, JP10.2
unnamed: EL11.1, JP11.2
unnamed: EL20.1, JP20.2
unnamed: EL30.1, JP30.2
unnamed: EL31.1, JP31.2
unnamed: EL40.1, JP40.2
unnamed: EL41.1, JP41.2
unnamed: R12.1, R13.1, U10.1
unnamed: R22.1, R23.1, U20.1
unnamed: R32.1, R33.1, U30.1
unnamed: R42.1, R43.1, U40.1
REF: C3.1, C4.2, C5.2, J1.3, J2.3, R10.2, R11.1, R13.2, R20.2, R21.1, R23.2, R30.2, R31.1, R33.2, R40.2, R41.1, R43.2, U10.5, U20.5, U30.5, U40.5
VCC: C1.2, C2.2, C3.2, C12.1, C22.1, C32.1, C42.1, J1.2, J2.2, U10.7, U10.8, U20.7, U20.8, U30.7, U30.8, U40.7, U40.8

## KiCad design schematics/circuit9.kicad_pcb

Parts:
BT1: 1.2V; BatteryHolder_Keystone_82_1xAAA
C1, C2, C3, C4, C5, C6, C7, C8, C9, C10, C11: 100uF; C_1206_3216Metric
J1: Left Pin Strip; PinSocket_1x15_P2.54mm_Vertical
J2: Right Pin Strip; PinSocket_1x15_P2.54mm_Vertical
J3: I/O Pin Strip; PinHeader_1x17_P2.54mm_Horizontal
JP1: Configuration Jumper; PinSocket_1x03_P2.54mm_Vertical
JP2, JP3: Solder Jumper; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 4.7uH; L_1206_3216Metric_Pad1.42x1.75mm_HandSolder
R1, R3, R4: 1M/1%; R_0805_2012Metric
R2: 110K/1%; R_0805_2012Metric
SW1: Power Switch; PinSocket_1x03_P2.54mm_Vertical
U1: TPS61220DCK; Texas_R-PDSO-G6
U2: LM321; SOT-23-5

Connections:
/+5V: J1.12
/A0: J1.4, J3.14
/A1: J1.5, J3.13
/A2: J1.6, J3.12
/A3: J1.7, J3.11
/A4: J1.8, J3.10
/A5: J1.9, J3.9
/A6: J1.10, J3.8
/A7: J1.11, J3.7, JP2.2 (B)
/AREF: J1.3
/D2: J2.11, JP1.3 (B)
/D3: J2.10, JP1.1 (A)
/D4: J2.9
/D5: J2.8
/D6: J2.7
/D7: J2.6
/D8: J2.5
/D9: J2.4
/D11: J2.2, J3.15
/D12: J2.1, J3.16
/D13: J1.1, J3.17
/FB: R1.2, R2.1, U1.2 (FB)
/GND: BT1.2 (-), C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J2.12, J3.1, J3.2, JP1.2 (C), R2.2, R4.2, U1.3 (GND), U2.2 (V-)
/GND2: J1.14
/L: L1.2, U1.5 (L)
/OpAmpV+: C7.1, JP3.2 (B), R3.1, U2.5 (V+)
/RST: J2.13
/RST2: J1.13
/RX: J2.14
/TX: J2.15
/V+: C3.1, C4.1, C5.1, C6.1, C10.1, C11.1, J1.2, J3.3, J3.4, JP3.1 (A), R1.1, U1.4 (VOUT)
/VIN: J1.15
/Vbat: C1.2, C2.2, J2.3, JP2.1 (A), L1.1, SW1.2 (B), U1.1 (VIN), U1.6 (EN)
/Vdiv: R3.2, R4.1, U2.1 (+)
/Vref: C8.1, C9.1, J3.5, J3.6, U2.3 (-), U2.4
unnamed: BT1.1 (+), SW1.1 (A)

Notes on the sheet:
2.5V
1.2V
Boost Converter from 1.2V to 5V
Reference Voltage Generator
Energy Source
Connector to Arduino Nano 33 BLE Sense
Allows measuring battery charge via analog pin A7
Input/Output Pin Strip
Multipurpose jumpers, software-configurable
Jumpers
https://psylink.me/c9

Board: 2 copper layers, 47.6 x 31.3 mm, 26 parts (2 on the bottom side), 22 nets.

## KiCad design schematics/orders/2022-01-26/bp4.2.kicad_pcb

Board: 2 copper layers, 90.0 x 32.6 mm, 42 parts (6 on the bottom side), 29 nets.

Parts:
BT1: 1.2V; BatteryHolder_Keystone_82_1xAAA
C1, C4, C5, C6, C8, C9, C10, C11: 10uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
C2, C3, C7: 100uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder
D1: Power LED; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder
J1: Left Pin Strip; PinSocket_1x15_P2.54mm_Vertical
J2: Right Pin Strip; PinSocket_1x15_P2.54mm_Vertical
J3: I/O Pin Strip; PinHeader_1x12_P2.54mm_Vertical
J4: Power Pins A; PinHeader_1x03_P2.54mm_Vertical
J5: Power Pins B; PinHeader_1x03_P2.54mm_Vertical
J6: Power Pins C; PinHeader_1x03_P2.54mm_Vertical
J7: External Power; PinHeader_1x02_P2.54mm_Vertical
JP1: Configuration Jumper; PinSocket_1x03_P2.54mm_Vertical
JP2, JP3: Solder Jumper; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
JP4, JP5, JP6, JP7, JP8: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
L1: 10uH; L_1210_3225Metric_Pad1.42x2.65mm_HandSolder
R1: 1M/1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R2, R3, R4: 110K/1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5: 100/1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
SW1: Power Switch; PinSocket_1x03_P2.54mm_Vertical
Screw1: Top Left; MountingHole_3.7mm_Pad
Screw2: Top Right; MountingHole_3.7mm_Pad
Screw3: Bottom Left; MountingHole_3.7mm_Pad
Screw4: Bottom Right; MountingHole_3.7mm_Pad
Screw5: Center; MountingHole_3.7mm_Pad
U1: TPS61220DCK; Texas_R-PDSO-G6
U2: LM321; SOT-23-5

Connections:
/A0: J1.4, J3.8
/A1: J1.5, J3.7
/A2: J1.6, J3.6
/A3: J1.7, J3.5
/A4: J1.8, J3.4
/A5: J1.9, J3.3
/A6: J1.10, J3.2
/A7: J1.11, J3.1, JP2.2
/D2: J2.11, JP1.3
/D3: J2.10, JP1.1
/D10: J2.3, J3.9
/D11: J2.2, J3.10
/D12: J2.1, J3.11
/D13: J1.1, J3.12
/FB: R1.2, R2.1, U1.2
/GND: BT1.2, C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, J2.12, J4.1, J5.1, J6.1, J7.1, JP1.2, R2.2, R4.2, R5.1, U1.3, U2.2
/L: L1.2, U1.5
/OpAmpV+: C7.1, JP3.2, R3.1, U2.5
/V+: C3.1, C4.1, C5.1, C6.1, C10.1, C11.1, D1.2, J1.2, J4.2, J5.2, J6.2, J7.2, JP3.1, R1.1, U1.4
/Vbat: C1.2, C2.2, JP2.1, L1.1, SW1.2, U1.1, U1.6
/Vdiv: R3.2, R4.1, U2.1
/Vref: C8.1, C9.1, J4.3, J5.3, J6.3, JP4.1, JP5.1, JP6.1, JP7.1, JP8.1, U2.3, U2.4
unnamed: BT1.1, SW1.1
unnamed: D1.1, R5.2
unnamed: JP4.2, Screw1.1
unnamed: JP5.2, Screw2.1
unnamed: JP6.2, Screw3.1
unnamed: JP7.2, Screw4.1
unnamed: JP8.2, Screw5.1

## KiCad design schematics/bp3.2.kicad_pcb

Board: 2 copper layers, 69.5 x 25.0 mm, 55 parts (3 on the bottom side), 39 nets.

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 100pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C9, C10, C11, C12: 100nF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
EL1, EL2, EL3, EL4, EL5, EL6, EL7, EL8: Electrode; MountingHole_3.7mm_Pad
EX1, EX2, EX3, EX4, EX5, EX6, EX7, EX8: ElectrodeTestPin; PinHeader_1x01_P2.54mm_Vertical
J1: PowerInput; PinHeader_1x03_P2.54mm_Vertical
J2: PowerPassThru; PinHeader_1x03_P2.54mm_Vertical
J3: OutputPins; PinHeader_1x04_P2.54mm_Vertical
JP1, JP2, JP3, JP4, JP5, JP6, JP7, JP8: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm
R1, R2, R3, R4, R5, R6, R7, R8: 1M/1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R9, R10, R11, R12: 100/1%; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
U1, U2, U3, U4: INA128; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
/in1: C1.1, EX1.1, JP1.1
/in2: C2.2, EX2.1, JP2.1
/in3: C3.1, EX3.1, JP3.1
/in4: C4.2, EX4.1, JP4.1
/in5: C6.2, EX5.1, JP5.1
/in6: C5.1, EX6.1, JP6.1
/in7: C8.2, EX7.1, JP7.1
/in8: C7.1, EX8.1, JP8.1
/out1: J3.1, U1.6
/out2: J3.2, U2.6
/out3: J3.3, U3.6
/out4: J3.4, U4.6
Earth: C9.2, C10.2, C11.2, C12.2, J1.1, J2.1, U1.4, U2.4, U3.4, U4.4
GNDS: J1.3, J2.3, R1.2, R2.1, R3.2, R4.1, R5.2, R6.1, R7.2, R8.1, U1.5, U2.5, U3.5, U4.5
unnamed: C1.2, R1.1, U1.3
unnamed: C2.1, R2.2, U1.2
unnamed: C3.2, R3.1, U2.3
unnamed: C4.1, R4.2, U2.2
unnamed: C5.2, R5.1, U3.3
unnamed: C6.1, R6.2, U3.2
unnamed: C7.2, R7.1, U4.3
unnamed: C8.1, R8.2, U4.2
unnamed: EL1.1, JP1.2
unnamed: EL2.1, JP2.2
unnamed: EL3.1, JP3.2
unnamed: EL4.1, JP4.2
unnamed: EL5.1, JP5.2
unnamed: EL6.1, JP6.2
unnamed: EL7.1, JP7.2
unnamed: EL8.1, JP8.2
unnamed: R9.1, U1.1
unnamed: R9.2, U1.8
unnamed: R10.1, U2.1
unnamed: R10.2, U2.8
unnamed: R11.1, U3.1
unnamed: R11.2, U3.8
unnamed: R12.1, U4.1
unnamed: R12.2, U4.8
VCC: C9.1, C10.1, C11.1, C12.1, J1.2, J2.2, U1.7, U2.7, U3.7, U4.7

## Commit log (part)

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2021-04-10 Added 1_initial_test
2021-04-10 Added code for steering wheel control
2021-04-10 cleaned up code
2021-04-11 Add passthrough arduino program to generate training data
2021-04-11 start writing a calibrator, so far it only gathers data
2021-04-11 don't just save the latest signal, keep last 64.
2021-04-11 credit debouncer
2021-04-11 fix NN label shape
2021-04-11 implemented saving/loading models
2021-04-11 updated gitignore
2021-04-12 more tweaks & fixes
2021-04-12 tinkering
2021-04-12 increase sensor resolution
2021-04-12 normalize electrode sensor readings to [0,1]
    I don't know if this is even necessary, but hey, let's add a bunch of
    unnecessary FLOPS to our main loop for elegance purposes. (I may revert
    this later...)
2021-04-12 fixed reuse of training data in validation on multiple trainings
2021-04-12 added README to calibrator code
2021-04-13 duplicated calibrator program to "4_model2"
2021-04-13 make labels binary
2021-04-13 use binary_accuracy as metric
2021-04-13 add updated arduino programs
2021-04-13 tweak neural network
2021-04-15 threaded serial reads, implemented fixed sampling rate & prediction rate
2021-04-15 added arduino files
2021-04-15 added DumbPipeFast that outputs samples at a fixed rate
2021-04-25 add schematic of design #4
2021-04-25 added schematics for older prototypes
2021-04-28 added schematic for circuit 0.5
2021-04-28 fixed typo in schematic 0.5
2021-04-29 update BLE code, streams a single signal at reasonable rate now
2021-04-29 rename BLE source block
2021-04-29 add shift block for a delay-free "rolling" plot with Qt GUI Time Sink
2021-04-29 add LICENSE
2021-04-30 added 0.5.1 schematic & pcb
2021-04-30 swap resistor for capacitor...
2021-05-01 add newest pcb layout
2021-05-04 raise the number of signals to 8
2021-05-04 add README
2021-05-04 Disable BLENotify feature in arduino code, BLERead should be enough
2021-05-04 removed old debug/performance measurement code
2021-05-04 add metadata characteristic for # channels, visualize dropped packets
2021-05-04 add empty worksheet
2021-05-04 add buggy PCBs for documentation purposes
2021-05-04 add test script for bleak BLE library
2021-05-04 Boost BLE rate from 1kb/s to 6-7kb/s (on my setup)
    GNURadio only runs with ~3kb/s due to overhead
    This was mainly accomplished by lowering the BLE connection interval to
    ~10ms. Unfortunately it eats up considerably more power now. Got the
    idea thanks to this comment:
    https://devzone.nordicsemi.com/f/nordic-q-a/7620/ble-gatt-read-characteristic-slow-or-normal/27191#27191
2021-05-04 dim bluetooth indicator LED
2021-05-05 started writing a python library
2021-05-05 update gitignore
2021-05-05 rename
2021-05-05 add documentation
2021-05-05 add basic MyocularUI program
2021-05-05 connect to BLE, collect samples, visualize them in rolling colors
2021-05-05 prettier columns, safer BLE connecting/disconnecting
2021-05-05 draw multiple lines at a time
2021-05-05 move SIGNAL_BUFFER_SIZE to pyocular.config
2021-05-06 add unit testing script
2021-05-06 add keycapturer to controller
2021-05-06 add pylint -E to test.sh
2021-05-06 fix pylint errors
2021-05-06 add "Run name" field, debug action (on F1 press)
2021-05-06 add epochs setting field
2021-05-06 display number of channels on BLE connect
2021-05-06 avoid double-crash when UI crashes on initialization
2021-05-06 draft AI menu
2021-05-06 turn irrelevant warning into info
2021-05-06 turn exception into a warning
2021-05-06 remove debug prints
2021-05-06 WIP on prediction
2021-05-06 implement saving/loading recorded samples
2021-05-07 implement saving/loading model
2021-05-07 eliminate redundant AI.label_order variable
2021-05-07 move all saved data into "save_{run_name}" directory
2021-05-07 fix key format in keycapturer unit test
2021-05-07 implement key pressing
2021-05-07 allow passing raw strings to keycapturer
2021-05-07 in pylint test, add pynput.keyboard.Key to generated members
2021-05-07 implement resetting AI, and build training data only when needed
2021-05-07 fix crash when loading recordings and recording again
2021-05-07 renamed myocular to psylink
2021-05-07 added bleak_sync_connect.py
2021-05-08 s/Myocular/PsyLink
2021-05-08 add AnalogToBLE.ino to arduino directory (copy of 5_ble/arduino/BLEpipe2)
2021-05-08 change name to PsyLink in arduino code
2021-05-08 moved R&D directories to "experimental" subdirectory
2021-05-08 fix pymyocular library loading in gnuradio program
2021-05-08 update gitignore/gnuradio
2021-05-08 better datasheet
2021-05-08 README improvements
2021-05-08 specify that it's kicad schematics
2021-05-08 clearer application
2021-05-08 add pictures
2021-05-08 rephrased and moved things
2021-05-08 add pcb picture
2021-05-08 add link to a video demo
2021-05-10 add psylink6.sch
2021-05-12 updated picture/video links
2021-05-12 add weight
2021-05-12 add psylink6 PCB
2021-05-17 add dependencies to README
2021-05-17 set channels to 7, adjust gnuradio script
2021-05-17 increase sample resolution
2021-05-17 better compression function for sampling delays
2021-05-17 migrate gnuradio code from experimental/5_ble to python/psylink
2021-05-17 add warnings to gnuradio files
2021-05-17 add multi-channel support to gnuradio shift block
2021-05-17 removed unused imports
2021-05-17 indicate BLE packet loss
2021-05-17 fix order of magnitude of sample intervals
2021-05-17 accumulate sample metrics between renderings
    instead of just showing the metrics of the last packet
2021-05-18 add feature flag for NRF52_MBED_TimerInterrupt.h
2021-05-18 rename GUI tool from MyocularUI to PsyLink UI
2021-05-18 style
2021-05-18 add timestamp to BLE packet
2021-05-18 stop drawing signals during AI training
2021-05-18 tweak AI again
2021-05-18 renamed SAMPLES_PER_INTERVAL to SAMPLES_PER_NOTIFY
2021-05-18 transmit and receive IMU data (gyroscope, accelerometer)
2021-05-18 reverse how samples are attached to SignalBuffer
2021-05-18 more accurate step count
2021-05-18 prevent division by zero
2021-05-19 increase EMG channels to 8 in GNURadio too
2021-05-19 support for a few selected special characters
    not all, because that produced weird behavior where keys appeared to be
    permanently pressed
2021-06-02 rename circuits/PCBs
2021-06-03 add circuit7 schematic
2021-06-04 add c8 + bp2 + Keystone 82 footprint
2021-06-15 add circuit9 schematic + pcb
2021-06-15 minor schematic tweak
2021-06-15 rename old order folder
2021-06-15 update circuits & order
2021-06-17 fix bugs in circuit9 schematic + pcb
2021-06-17 add tools to automate image generation for website
2021-06-17 finalized 2021-06-15 order
2021-07-01 get backend class from argument
2021-07-01 implement early stopping during AI training
2021-07-25 fix comment
2021-07-25 indefinite run time
2021-07-25 change default BLE address
2021-07-25 move gnuradio code to subdirectory "prototype4"
2021-07-25 add gnumeric code for prototype6
2021-07-27 more precise comment
2021-07-27 measure bytes per BLE packet
2021-08-01 WIP compression of signals
2021-08-01 tweak gnuradio flowgraph, change default MAC address
2021-09-14 Larger pads on bp3.1 for easier soldering (fixes #8)
2021-09-15 updated/finalized bp3.1 (makes room for 1210 package inductance)
2021-09-17 started working on quad inst.amp. circuit
2021-09-30 finished circuit10 + board3
2021-09-30 polished b3
2021-09-30 enlarge rubber band holes
2021-09-30 final polishing of b3 before ordering
2021-10-06 added schematics/ordered/bp3.1.kicad_pcb
2021-10-06 fix missing connections at EX4 and EX8
2021-12-11 added circuit 11 and small changes to bp4
2021-12-11 WIP bp4
2021-12-11 routed bp4, jumpers & labels missing tho
2021-12-12 finished bp4 (or so it seems)
2021-12-15 better comments in circuit11
2021-12-19 move SW1 to the left to make space for larger power switches
2021-12-19 move JP8 away from battery clip to avoid short circuit with ground
2021-12-19 swap horizontal pin headers for vertical pin headers
2021-12-19 restore original bp4 and rename the updated one to bp4.1
2021-12-19 update model name to bp4.1 on silk screen
2021-12-19 started working on revising b3, added b3.1
2021-12-19 add "(voltage setter)" label to R2 in bp4.1
2021-12-19 enlarge contact pads for electrode screws for b3.1
2022-01-06 break ground loop on back side of b3.1
2022-01-06 On b3.1, route EX1-C1 past EL1, to allow cutting C1-EL1 if needed
    same for EX2-C2 and EL2, and all the other electrodes
    You may want to use external electrodes with the board, but you
    currently can neither disable the built-in EL1-EL8 electrodes, nor can
    you remove them since they're used for physical support. Ideally there
    should be a jumper, but there's little space. So for the time being, if
    you really want to disconnect the electrodes, you can now cut the copper
2022-01-07 On b3.1, add jumpers for electrodes, so u can quickly switch to external ones
2022-01-07 polish bp4.1 and circuit11.1
2022-01-07 remove accidentally added WIP file circuit11.1.sch
2022-01-21 add software configuration info to readme
2022-01-26 draw rectangles around gain resistors
2022-01-26 hide U* labels under chips. add "signal*" labels.
2022-01-26 grow INA128's solder pads for easier assembly
2022-01-26 tweak silkscreen
2022-01-26 add silkscreen on backside for signals and electrode polarity
2022-01-26 improve logo
2022-01-26 add c12.1 and bp4.2, containing simplifications/optimizations
2022-01-26 fix name of schematic (bp3.2 -> b3.2)
    Those names are starting to get confusing...
2022-02-01 double resistance on R10, add comment
2022-02-01 Add AnalogToBLE1.1 with different input signal ranges
2022-02-01 add 2022-01-26 PCB order
2022-02-01 add gnuradio program for prototype 9
2022-02-05 add comments about dependencies right into the arduino files
2022-02-14 allow partial imports of psylink modules
    this way, you can run GNURadio without prerequisites for gui.py or ai.py
2022-02-23 bump year in license
2022-02-23 Remove focus in GUI when pressing ESC (fixes #5)
2022-02-23 Add the good parts of PR #26 (thanks PerlinWarp!)
2022-04-26 Add new Electrode Module design from AntonX
2022-04-26 change labels (b3.2->b4, c10.2->c13)
2023-03-06 add gnuradio script that has been used to record sample data
2023-03-06 add "*-backups" to .gitignore
2023-04-06 Added AnalogToBLE1.2.ino, for P10
    Difference between 1.1 and 1.2 is only that in line 211, the surveyed
    voltage range is increased from 25%-75% to 0%-100% of Vcc, so that the
    higher voltage output with the 100nF highpass filter in P10 is covered.
2023-04-09 neater prototype9/plot_signals.grc
2023-04-09 update block_BLE_source.py file.
    Doesn't seem to be autogenerated anymore by GNURadio. Perhaps we should
    remove this file entirely. Or move most of it to the python library.
2023-04-10 remove erroneously commited order folders
2023-04-10 move orders to archive folder
2023-04-10 update filenames of autogenerated gnuradio blocks
    they still exist for reference
2023-04-10 Move out GNURadio block code into psylink.gnuradio_blocks module
2023-04-10 move loose kicad files to archive/kicad/
2023-04-10 ignore .py files in gnuradio directory (they're all autogenerated)
2023-04-10 add power_module4.2 folder
2023-04-10 ignore .kicad_prl files (local project settings)
2023-04-10 add electrode_module4 folder
2023-04-10 upgrade schematics (EM3.2, PM4.2) to KiCad 6
2023-04-10 Add README.md with pictures
2023-04-10 remove old kicad 5 files
2023-04-10 write error messages to STDERR instead of STDOUT
2023-04-15 better error messages
2023-04-15 reload psylink.gnuradio_blocks module when re-validating code
2023-04-16 add comments to bluetooth.py
2023-04-19 README: replace github links with codeberg links
2023-04-19 README: typo
2023-04-19 README: moved logo below header
2023-04-19 replaced logo and table by just one image
2023-04-19 README: changed Mastodon link from /media to home page
2023-04-24 bump date
2023-04-30 s/extra/additional/
2023-05-11 simplify matrix badge
    Before, it showed the user count, which would sometimes fail. This would
    make the badge look like: "Chat | Inaccessible", which looks like the
    chat is inaccessible... that's way worse than just having no user count.
2023-05-30 add comment to make_circuit_image.sh
2023-05-31 README: update photograph
2023-06-01 Add contributors
2023-08-24 add documentation for power module 4.2
2023-08-24 schematics: add example usage for bp4.2 as stand-alone breakout board

Notices in the files:
README.md:
License: GPL 3.0
