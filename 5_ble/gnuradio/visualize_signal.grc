options:
  parameters:
    generate_options: qt_gui
    id: grcmyocular
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: offset
  id: variable
  parameters:
    value: '64'
  states: {}
- name: points
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '250'
  states: {}
- name: block_BLE_source
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import math
      import BLE_GATT
      import time
      import importlib
      import os.path
      import sys
      from threading import Thread, Event
      from queue import SimpleQueue
      from gnuradio import gr

      # NOTE: fill in the path to the pymyocular library
      sys.path.insert(0, os.path.expanduser('~/repos/myocular/5_ble'))
      import pymyocular

      BLUETOOTH_ADAPTER = 'hci0'
      DEFAULT_BLE_ADDRESS = 'A6:B7:D0:AE:C2:76'
      SIGNAL_COUNT = 8
      USE_BLE = True


      def run_bluetooth_loop(device, sample_pipe, stop_thread):
          decoder = pymyocular.BLEDecoder()
          sps = 0
          bps = 0
          last_tick = None
          nextsps = time.time() + 1
          device.connect()
          try:
              decoder.decode_channel_count(device.char_read(pymyocular.BLEDevice.OPTION_CHANNELS_UUID))
              while not stop_thread.is_set():
                  t = time.time()
                  read = device.char_read(pymyocular.BLEDevice.SENSOR_UUID)
                  t = time.time() - t
                  data = decoder.decode_packet(read)
                  #print('[BLE] Received a packet of length %d, duration: %f, tick: %d' % (len(read), t, data['tick']))
                  samples = data['samples']
                  tick = data['tick']

                  if last_tick is not None:
                      if last_tick == tick:
                          # This packet has already been received
                          #print('Dropped packet, it has already been received')
                          continue

                      # Need to consider overflow of tick value. It's range is between 1 and incl. 255
                      #lost_packets = min(max(0, tick - last_tick - 1), tick + 255 - last_tick - 1)
                      #if lost_packets:
                      #    null_sample = np.zeros((data['channels'], lost_packets * len(samples)))
                      #    sample_pipe.put(null_sample)
                  last_tick = tick

                  #for sample in samples:
                      #sample_pipe.put(sample)
                  sample_pipe.put(samples)

                  bps += len(read)
                  sps += len(samples)
                  if time.time() >= nextsps:
                      print(f"SPS: {sps}, BPS: {bps}")
                      nextsps += 1
                      sps = 0
                      bps = 0
          finally:
              device.disconnect()


      class BLESource(gr.basic_block):
          def __init__(self, ble_mac=DEFAULT_BLE_ADDRESS):
              gr.basic_block.__init__(self, name='BLE Source', in_sig=[], out_sig=[np.float32] * SIGNAL_COUNT)
              self.ble_mac = ble_mac
              self.sample_pipe = SimpleQueue()
              self.stop_thread = Event()
              self.last_sample_count = 2048  # some large conservative value
              self.device = BLE_GATT.Central(ble_mac)
              self._bt_thread = None

          def general_work(self, input_items, output_items):
              count = 0
              if USE_BLE:
                  limit = len(output_items[0]) - self.last_sample_count
                  while not self.sample_pipe.empty() and count < limit:
                      samples = self.sample_pipe.get()
                      transposed = np.transpose(samples)
                      for channel_id, channel in enumerate(output_items):
                          channel[count:count+len(samples)] = transposed[channel_id]
                      count += len(samples)
                      self.last_sample_count = len(samples)
                      limit = len(output_items[0]) - self.last_sample_count
              else:
                  for i in range(min(100, len(output_items[0]))):
                      output_items[0][i] = math.sin(i)
                      count += 1
              return count

          def start(self):
              if not USE_BLE:
                  return True
              if self._bt_thread:
                  print("Error: Bluetooth Thread already running!")
                  return False

              # Reset state
              importlib.reload(pymyocular)
              self.stop_thread.clear()
              while not self.sample_pipe.empty():
                  self.sample_pipe.get()

              # Launch thread
              self._bt_thread = Thread(
                  target=run_bluetooth_loop,
                  args=(self.device, self.sample_pipe, self.stop_thread)
              )
              self._bt_thread.start()
              return True

          def stop(self):
              if not USE_BLE:
                  return True
              self.stop_thread.set()
              self._bt_thread = None

              return True
    ble_mac: '''A6:B7:D0:AE:C2:76'''
  states: {}
- name: block_shift
  id: epy_block
  parameters:
    _source_code: |
      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: block_shift_0_0_0_0_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Keeps a copy of the last N signals and outputs them at a constant rate,
      so that you can use QT GUI sinks in a "rolling" mode.
      """

      import numpy as np
      from gnuradio import gr


      class ShiftBlock(gr.interp_block):
          def __init__(self, number_of_points=1024):
              gr.interp_block.__init__(
                  self,
                  name='Shifting Block',
                  interp=10 * number_of_points,  # a large number to ensure that output_items is large enough
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.number_of_points = number_of_points
              self.buffer = np.zeros(self.number_of_points, dtype=np.float64)

          def work(self, input_items, output_items):
              n_inputs = min(self.number_of_points, len(input_items[0]))
              self.buffer = np.roll(self.buffer, -n_inputs)
              self.buffer[-n_inputs:] = input_items[0][:n_inputs]
              output_items[0][:self.number_of_points] = self.buffer
              self.consume(0, n_inputs)
              return self.number_of_points
    number_of_points: points
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 2*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 3*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 4*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 5*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 6*offset
    type: float
  states: {}
- name: blocks_add_const_vxx_0_0_0_0_0_0_0
  id: blocks_add_const_vxx
  parameters:
    const: 7*offset
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: points
    freqhalf: 'False'
    grid: 'True'
    nconnections: '2'
    type: float
    update_time: '0.05'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '40'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    nconnections: '8'
    size: points
    srate: samp_rate
    type: float
    update_time: '0.05'
    ymax: 128 + 7 * offset
    ymin: '-128'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    entags: 'False'
    grid: 'True'
    nconnections: '8'
    size: points
    srate: samp_rate
    type: float
    update_time: '0.05'
    ymax: 128 + 7 * offset
    ymin: '-128'
  states: {state: disabled}

connections:
- [block_BLE_source, '0', block_shift, '0']
- [block_BLE_source, '0', qtgui_time_sink_x_0_0, '0']
- [block_BLE_source, '1', block_shift_0, '0']
- [block_BLE_source, '1', qtgui_time_sink_x_0_0, '1']
- [block_BLE_source, '2', block_shift_0_0, '0']
- [block_BLE_source, '2', qtgui_time_sink_x_0_0, '2']
- [block_BLE_source, '3', block_shift_0_0_0, '0']
- [block_BLE_source, '3', qtgui_time_sink_x_0_0, '3']
- [block_BLE_source, '4', block_shift_0_0_0_0, '0']
- [block_BLE_source, '4', qtgui_time_sink_x_0_0, '4']
- [block_BLE_source, '5', block_shift_0_0_0_0_0, '0']
- [block_BLE_source, '5', qtgui_time_sink_x_0_0, '5']
- [block_BLE_source, '6', block_shift_0_0_0_0_0_0, '0']
- [block_BLE_source, '6', qtgui_time_sink_x_0_0, '6']
- [block_BLE_source, '7', block_shift_0_0_0_0_0_0_0, '0']
- [block_BLE_source, '7', qtgui_time_sink_x_0_0, '7']
- [block_shift, '0', qtgui_freq_sink_x_0, '0']
- [block_shift, '0', qtgui_time_sink_x_0, '0']
- [block_shift_0, '0', blocks_add_const_vxx_0, '0']
- [block_shift_0, '0', qtgui_freq_sink_x_0, '1']
- [block_shift_0_0, '0', blocks_add_const_vxx_0_0, '0']
- [block_shift_0_0_0, '0', blocks_add_const_vxx_0_0_0, '0']
- [block_shift_0_0_0_0, '0', blocks_add_const_vxx_0_0_0_0, '0']
- [block_shift_0_0_0_0_0, '0', blocks_add_const_vxx_0_0_0_0_0, '0']
- [block_shift_0_0_0_0_0_0, '0', blocks_add_const_vxx_0_0_0_0_0_0, '0']
- [block_shift_0_0_0_0_0_0_0, '0', blocks_add_const_vxx_0_0_0_0_0_0_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_time_sink_x_0, '1']
- [blocks_add_const_vxx_0_0, '0', qtgui_time_sink_x_0, '2']
- [blocks_add_const_vxx_0_0_0, '0', qtgui_time_sink_x_0, '3']
- [blocks_add_const_vxx_0_0_0_0, '0', qtgui_time_sink_x_0, '4']
- [blocks_add_const_vxx_0_0_0_0_0, '0', qtgui_time_sink_x_0, '5']
- [blocks_add_const_vxx_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '6']
- [blocks_add_const_vxx_0_0_0_0_0_0_0, '0', qtgui_time_sink_x_0, '7']

metadata:
  file_format: 1
